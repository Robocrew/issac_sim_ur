Commit message: ur_workspace added successfully

File: urdf/main_ws.urdf (robot description, URDF)
Before this commit: robot ur, 59 links, 58 joints
Joints:
- joint table_joint: origin xyz=0 1.317 0 rpy=0 0 0 -> xyz=0 1.317 0 rpy=3.14 0 0
